# Keil uVision project DES_M0_SoC_Basic_Uart.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: DES_M0_SoC +hex
  AfterMake: fromelf .\temp_files\DES_M0_SoC.axf --vhx --32x1 -o ROMcode.hex
  AfterMake: fromelf -cvf .\temp_files\DES_M0_SoC.axf -o .\temp_files\disasm.txt
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c retarget.c cm0dsasm.s ledDisplayTestMain.c spiTestMain.c
